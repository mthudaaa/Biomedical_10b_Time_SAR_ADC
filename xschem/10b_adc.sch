v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {th_sw.sym} 430 -410 0 0 {name=x2}
C {sar.sym} 870 -220 0 0 {name=x4}
C {devices/lab_wire.sym} 280 -460 0 0 {name=p1 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 280 -280 0 0 {name=p2 sig_type=std_logic lab=VDDR}
C {devices/lab_wire.sym} 720 -460 0 0 {name=p3 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 720 -380 0 0 {name=p4 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 280 -180 0 0 {name=p5 sig_type=std_logic lab=VSSR}
C {devices/lab_wire.sym} 280 -360 0 0 {name=p6 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 720 -280 0 0 {name=p7 sig_type=std_logic lab=VDDD}
C {devices/lab_wire.sym} 720 -200 0 0 {name=p8 sig_type=std_logic lab=VSSD}
C {devices/lab_wire.sym} 280 -420 0 0 {name=p9 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 280 -440 0 0 {name=p10 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 1020 -280 0 1 {name=p11 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 1020 -260 0 1 {name=p12 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 720 -220 0 0 {name=p15 sig_type=std_logic lab=COMP_N}
C {devices/lab_wire.sym} 720 -260 0 0 {name=p17 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 580 -460 0 1 {name=p18 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 580 -440 0 1 {name=p19 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 580 -280 0 1 {name=p20 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 580 -260 0 1 {name=p21 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 720 -420 0 0 {name=p22 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 720 -400 0 0 {name=p23 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 720 -440 0 0 {name=p25 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 280 -200 0 0 {name=p26 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 280 -400 0 0 {name=p27 sig_type=std_logic lab=VIP}
C {devices/lab_wire.sym} 280 -380 0 0 {name=p28 sig_type=std_logic lab=VIN}
C {devices/lab_wire.sym} 280 -260 0 0 {name=p29 sig_type=std_logic lab=CF[0:9]}
C {devices/lab_wire.sym} 280 -240 0 0 {name=p30 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 280 -220 0 0 {name=p31 sig_type=std_logic lab=SWN[0:9]}
C {devices/lab_wire.sym} 1020 -240 0 1 {name=p32 sig_type=std_logic lab=CF[0:9]}
C {devices/lab_wire.sym} 1020 -220 0 1 {name=p33 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 1020 -200 0 1 {name=p34 sig_type=std_logic lab=SWN[0:9]}
C {devices/lab_wire.sym} 1020 -160 0 1 {name=p35 sig_type=std_logic lab=CKO}
C {devices/lab_wire.sym} 1020 -180 0 1 {name=p36 sig_type=std_logic lab=DOUT[0:9]}
C {devices/ipin.sym} 80 -480 0 0 {name=p37 sig_type=std_logic lab=VDDA}
C {devices/ipin.sym} 80 -460 0 0 {name=p38 sig_type=std_logic lab=VDDD}
C {devices/ipin.sym} 80 -440 0 0 {name=p39 sig_type=std_logic lab=VCM}
C {devices/ipin.sym} 80 -420 0 0 {name=p40 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 80 -400 0 0 {name=p41 sig_type=std_logic lab=VIP}
C {devices/ipin.sym} 80 -380 0 0 {name=p42 sig_type=std_logic lab=VIN}
C {devices/ipin.sym} 80 -340 0 0 {name=p43 sig_type=std_logic lab=VSSA}
C {devices/ipin.sym} 80 -320 0 0 {name=p44 sig_type=std_logic lab=VSSD}
C {devices/opin.sym} 60 -240 0 0 {name=p45 sig_type=std_logic lab=DOUT[0:9]}
C {devices/opin.sym} 60 -220 0 0 {name=p46 sig_type=std_logic lab=CKO}
C {devices/lab_wire.sym} 1020 -420 0 1 {name=p47 sig_type=std_logic lab=RDY}
C {cdac_10b.sym} 430 -230 0 0 {name=x1}
C {tdc.sym} 870 -420 0 0 {name=x3}
C {devices/ipin.sym} 80 -360 0 0 {name=p14 sig_type=std_logic lab=VSSR}
C {devices/ipin.sym} 80 -500 0 0 {name=p16 sig_type=std_logic lab=VDDR}
C {devices/lab_wire.sym} 720 -240 0 0 {name=p24 sig_type=std_logic lab=COMP_P}
C {devices/lab_wire.sym} 1020 -460 0 1 {name=p13 sig_type=std_logic lab=COMP_P}
C {devices/lab_wire.sym} 1020 -440 0 1 {name=p48 sig_type=std_logic lab=COMP_N}
