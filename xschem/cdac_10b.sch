v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {10b_cap_array.sym} 570 -340 0 0 {name=x1}
C {cdac_sw.sym} 570 -450 0 0 {name=x2[0:11]}
C {cdac_sw.sym} 570 -570 0 0 {name=x3[0:11]}
C {devices/lab_wire.sym} 420 -610 0 0 {name=p1 sig_type=std_logic lab=vdref}
C {devices/lab_wire.sym} 420 -490 0 0 {name=p2 sig_type=std_logic lab=vdref}
C {devices/lab_wire.sym} 420 -530 0 0 {name=p3 sig_type=std_logic lab=vsref}
C {devices/lab_wire.sym} 420 -410 0 0 {name=p4 sig_type=std_logic lab=vsref}
C {devices/lab_wire.sym} 720 -610 2 0 {name=p5 sig_type=std_logic lab=swp[0:9]}
C {devices/lab_wire.sym} 420 -330 0 0 {name=p6 sig_type=std_logic lab=swp[0:9]}
C {devices/lab_wire.sym} 720 -490 2 0 {name=p7 sig_type=std_logic lab=swn[0:9]}
C {devices/lab_wire.sym} 420 -250 0 0 {name=p8 sig_type=std_logic lab=swn[0:9]}
C {devices/lab_wire.sym} 420 -350 0 0 {name=p9 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -430 0 0 {name=p10 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -550 0 0 {name=p11 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 420 -590 0 0 {name=p12 sig_type=std_logic lab=cf[0:9]}
C {devices/lab_wire.sym} 420 -470 0 0 {name=p13 sig_type=std_logic lab=cf[0:9]}
C {devices/lab_wire.sym} 420 -570 0 0 {name=p14 sig_type=std_logic lab=swp_in[0:9]}
C {devices/lab_wire.sym} 420 -450 0 0 {name=p15 sig_type=std_logic lab=swn_in[0:9]}
C {devices/lab_wire.sym} 720 -350 0 1 {name=p16 sig_type=std_logic lab=vcp}
C {devices/lab_wire.sym} 720 -270 0 1 {name=p17 sig_type=std_logic lab=vcn}
C {devices/ipin.sym} 180 -620 0 0 {name=p18 lab=vdref}
C {devices/ipin.sym} 180 -590 0 0 {name=p19 lab=cf[0:9]}
C {devices/ipin.sym} 180 -560 0 0 {name=p20 lab=swp_in[0:9]}
C {devices/ipin.sym} 180 -530 0 0 {name=p21 lab=swn_in[0:9]}
C {devices/ipin.sym} 180 -500 0 0 {name=p22 lab=vcm}
C {devices/ipin.sym} 180 -470 0 0 {name=p23 lab=vsref}
C {devices/iopin.sym} 160 -440 0 0 {name=p24 lab=vcp}
C {devices/iopin.sym} 160 -410 0 0 {name=p25 lab=vcn}
C {10b_cap_array.sym} 570 -260 0 0 {name=x2}
C {devices/lab_wire.sym} 420 -270 0 0 {name=p27 sig_type=std_logic lab=vcm}
