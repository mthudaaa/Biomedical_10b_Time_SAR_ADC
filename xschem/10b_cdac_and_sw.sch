v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {cdac_sw.sym} 410 -430 0 0 {name=x2[0:11]}
C {cdac_sw.sym} 410 -310 0 0 {name=x3[0:11]}
C {devices/lab_wire.sym} 260 -470 0 0 {name=p2 sig_type=std_logic lab=vdda}
C {devices/lab_wire.sym} 260 -350 0 0 {name=p3 sig_type=std_logic lab=vdda}
C {devices/lab_wire.sym} 260 -270 0 0 {name=p4 sig_type=std_logic lab=vssa}
C {devices/lab_wire.sym} 260 -390 0 0 {name=p5 sig_type=std_logic lab=vssa}
C {devices/lab_wire.sym} 260 -410 0 0 {name=p6 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 260 -290 0 0 {name=p7 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 820 -470 0 0 {name=p8 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 260 -450 0 0 {name=p9 sig_type=std_logic lab=cf[0:10]}
C {devices/lab_wire.sym} 260 -330 0 0 {name=p10 sig_type=std_logic lab=cf[0:10]}
C {devices/lab_wire.sym} 260 -430 0 0 {name=p11 sig_type=std_logic lab=swp[0:10]}
C {devices/lab_wire.sym} 260 -310 0 0 {name=p12 sig_type=std_logic lab=swn[0:10]}
C {devices/lab_wire.sym} 820 -450 0 0 {name=p13 sig_type=std_logic lab=dac_outp[0:9]}
C {devices/lab_wire.sym} 820 -330 0 0 {name=p14 sig_type=std_logic lab=dac_outn[0:9]}
C {devices/lab_wire.sym} 560 -470 0 1 {name=p15 sig_type=std_logic lab=dac_outp[0:9]}
C {devices/lab_wire.sym} 560 -350 0 1 {name=p16 sig_type=std_logic lab=dac_outn[0:10]}
C {devices/lab_wire.sym} 1120 -470 0 1 {name=p17 sig_type=std_logic lab=vcp}
C {devices/lab_wire.sym} 1120 -350 0 1 {name=p18 sig_type=std_logic lab=vcn}
C {devices/ipin.sym} 80 -460 0 0 {name=p1 sig_type=std_logic lab=vdda}
C {devices/ipin.sym} 80 -420 0 0 {name=p19 sig_type=std_logic lab=cf[0:3]}
C {devices/ipin.sym} 80 -440 0 0 {name=p20 sig_type=std_logic lab=vcm}
C {devices/ipin.sym} 80 -400 0 0 {name=p21 sig_type=std_logic lab=swp[0:3]}
C {devices/ipin.sym} 80 -380 0 0 {name=p22 sig_type=std_logic lab=swn[0:3]}
C {devices/ipin.sym} 80 -360 0 0 {name=p23 sig_type=std_logic lab=vssa}
C {devices/iopin.sym} 80 -320 0 1 {name=p24 sig_type=std_logic lab=vcp}
C {devices/iopin.sym} 80 -300 0 1 {name=p25 sig_type=std_logic lab=vcn}
C {10b_cap_array.sym} 970 -460 0 0 {name=x1}
C {devices/lab_wire.sym} 820 -350 0 0 {name=p26 sig_type=std_logic lab=vcm}
C {10b_cap_array.sym} 970 -340 0 0 {name=x2}
